# Keil uVision project Serial_Dave.uvproj, settings and files
target Target 1 (166/167)
  device: C167CS-LM Infineon
  cpu: IRAM(0xF200-0xFDFF) XRAM(0xE000-0xE7FF) XRAM2 (0xC000-0xD7FF) ICAN(0xE800-0xEFFF) CLOCK(25000000) MOD167
  output: Serial_Dave +hex
  group Source Group 1
    ./: MAIN.C ASC0.C GPT1.C IO.C CAN1.C project.asm C167_Init-2.a66
